# IAR project LAB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS\Include\; CMSIS\Device\ST\STM32F4xx\Include\; StdPeriph\inc\; FreeRTOS\Source\include\; FreeRTOS\Source\portable\IAR\ARM_CM4F\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: LAB.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group FreeRTOS
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/: list.c queue.c tasks.c
    FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group StdPeriph
    StdPeriph/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
